# Keil uVision project LED.uvprojx, settings and files
target LED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,USE_MPU6050DMP = 0,USE_ICM42605 = 0
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE;..\HARDWARE\Timer;..\HARDWARE\HongWai;..\HARDWARE\ICM20602orMPU6050;..\HARDWARE\LCD;..\HARDWARE\Encoder;..\HARDWARE\Motor;..\HARDWARE\Timer;..\HARDWARE\control;..\HARDWARE\ICM42605;..\ALGORITHM\Kalman;..\ALGORITHM\Mahony;..\ALGORITHM\PID;..\HARDWARE\AII_init
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
    ../HARDWARE/control/: control.c
  group ALGORITHM
    ../ALGORITHM/PID/: PID.c
    ../ALGORITHM/Kalman/: kalman.c
    ../ALGORITHM/Mahony/: Mahony.c imu.c
  group HARDWARE
    ../HARDWARE/AII_init/: All_init.c
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/Motor/: Motor.c
    ../HARDWARE/Encoder/: Encoder.c
    ../HARDWARE/LCD/: LCD.c
    ../HARDWARE/Timer/: Timer.c
    ../HARDWARE/ICM20602orMPU6050/: i2c.c ICM20602orMPU6050.c inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/ICM42605/: ICM42605.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
    ./: stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c
  group README
    ../: README.TXT
